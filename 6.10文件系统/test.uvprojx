# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER.STM32F10X_HD
  c include: .\User;.\Library\CMSIS;.\Library\STM32F10x_StdPeriph_Driver\inc;.\public;.\APP;.\APP\ff11a\doc;.\APP\ff11a\src;.\APP\ff11a\src\option
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startuo
    ./Library/CMSIS/: startup_stm32f10x_hd.s
  group CMSIS
    ./Library/CMSIS/: core_cm3.c system_stm32f10x.c
  group STD
    ./Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Public
    ./public/: system.c systick.c usart.c
  group APP
    ./APP/: LED.c key.c tftlcd.c front.h spi_flash.c
  group FAT
    ./APP/ff11a/src/: diskio.c ff.c
