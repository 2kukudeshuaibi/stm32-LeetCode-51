# Keil uVision project 八路抢答器.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 八路抢答器 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c keyscan.c keyscan.h Public.c Public.h LCD1602.c LCD1602.h
